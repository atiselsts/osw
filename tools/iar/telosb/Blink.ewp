# IAR project Blink.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CPU_MHZ=4; PLATFORM_TELOSB=1; MCU_MSP430=1; USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_ADC; USE_SERIAL; USE_SPI; USE_CRC; USE_LEDS; USE_ALARMS; USE_ASSERT; USE_RADIO; USE_PRINT
  ICC430.newCCIncludePaths: ..\..\..\mos; ..\..\..\mos\kernel; ..\..\..\mos\platforms\telosb; ..\..\..\mos\arch\msp430; ..\..\..\mos\chips
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../mos/hil/: adc.c adc.h alarms.h errors.c errors.h gpio.h leds.c leds.h spi.c spi.h usart.c usart.h
    ../../../mos/kernel/: alarms.c alarms_system.h defines.h defines_iar.h kernelmain.c sleep.c
    ../../../mos/lib/: assert.c assert.h dprint.c dprint.h
    ../../../mos/chips/cc2420/: cc2420.c cc2420.h cc2420_const.h cc2420_spi.h
    ../../../mos/platforms/telosb/: flash.h ledslist.h platform.c platform.h
    ../../../mos/arch/msp430/: gpio_hal.h udelay_hal.h
    ../../../apps/demo/Blink/: main.c
    ../../../mos/chips/msp430/: msp430_adc.h msp430_clock.h msp430_int.h msp430_timers.c msp430_timers.h msp430_usart.c msp430_usart.h msp430_usart_spi.c msp430_usart_spi.h msp430x1xx_clock.c
    ../../../mos/kernel/nothreads/: timing.c
