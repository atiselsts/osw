# IAR project Blink5.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CPU_MHZ=4; PLATFORM_TELOSB=1; MCU_MSP430=1; USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_SERIAL; USE_SPI; USE_CRC; USE_LEDS; USE_ALARMS; USE_ASSERT; USE_PRINT
  ICC430.newCCIncludePaths: ..\..\..\src; ..\..\..\src\kernel; ..\..\..\src\platforms\sm3; ..\..\..\src\arch\msp430; ..\..\..\src\chips
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: CPU_MHZ=4; PLATFORM_TELOSB=1; MCU_MSP430=1; USE_KERNEL_MAIN; USE_HARDWARE_TIMERS; USE_ADC; USE_SERIAL; USE_SPI; USE_CRC; USE_LEDS; USE_ALARMS; USE_ASSERT; USE_RADIO; USE_PRINT
  ICC430.newCCIncludePaths: ..\..\..\src; ..\..\..\src\kernel; ..\..\..\src\platforms\telosb; ..\..\..\src\arch\msp430; ..\..\..\src\chips
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../src/kernel/: alarms.c alarms_system.h defines.h defines_iar.h kernelmain.c sleep.c
    ../../../src/hil/: alarms.h errors.c errors.h gpio.h leds.c leds.h spi.c spi.h usart.c usart.h
    ../../../src/platforms/sm3/: amb8420_pins.h flash.h ledslist.h platform.c platform.h platform_radio.h sht_pins.h
    ../../../src/lib/: assert.c assert.h dprint.c dprint.h
    ../../../src/platforms/telosb/: flash.h ledslist.h
    ../../../src/arch/msp430/: gpio_hal.h udelay_hal.h
    ../../../apps/demo/Blink/: main.c
    ../../../src/chips/msp430/: msp430_adc.h msp430_clock.h msp430_int.h msp430_timers.c msp430_timers.h msp430_usci.h msp430_usci_i2c.c msp430_usci_spi.c msp430_usci_uart.c msp430x5xx_clock.c
    ../../../src/kernel/nothreads/: timing.c
